# Keil uVision project demo.uvproj, settings and files
target demo (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fsmc
  c flags: Optim=1
  c define: NDEBUG, STM32F10X_CL, NO_PRINTF, NO_QWORD, INIT_SERIAL
  c misc: --c99
  c include: .\include;.\config;.\STM32_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ./: startup_stm32f10x_hd.s
  group driver
    ./driver/: rcc.c usart.c cdrvbxcan.c target.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group main
    ./main/: main.c
  group USB-FS-Device-driver
    ./STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
